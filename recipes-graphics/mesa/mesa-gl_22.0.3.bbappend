# Copyright 2025 NXP

MIRRORS += " \
    https://mesa.freedesktop.org/.*	https://downloads.yoctoproject.org/mirror/sources/ \
"
