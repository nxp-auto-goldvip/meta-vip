# Copyright 2025 NXP

MIRRORS += " \
    http://icedtea.classpath.org/.*	https://downloads.yoctoproject.org/mirror/sources/ \
"