# Copyright 2025 NXP

MIRRORS += " \
    http://ftp.gnu.org/gnu/classpathx/.*	https://www.multitech.net/mlinux/sources/ \
"
