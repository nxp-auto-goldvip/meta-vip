# Copyright 2025 NXP

MIRRORS += " \
    http://ftp.gnu.org/gnu/classpath/.*	https://www.multitech.net/mlinux/sources/ \
"
