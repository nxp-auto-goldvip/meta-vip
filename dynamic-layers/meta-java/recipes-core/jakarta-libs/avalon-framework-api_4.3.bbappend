# Add mirror to account for apache.org hosting path changes (https://github.com/meta-java/meta-java/issues/55).
MIRRORS += "https://.*/.*    https://archive.apache.org/dist/excalibur/excalibur-framework/source/"
