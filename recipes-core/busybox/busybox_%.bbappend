FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://vip.cfg"
